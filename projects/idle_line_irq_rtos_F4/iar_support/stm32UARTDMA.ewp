# IAR project stm32UARTDMA.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F413ZH ST STM32F413ZH
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; HSE_VALUE=25000000; HSE_STARTUP_TIMEOUT=100; LSE_STARTUP_TIMEOUT=5000; LSE_VALUE=32768; EXTERNAL_CLOCK_VALUE=12288000; HSI_VALUE=16000000; LSI_VALUE=32000; VDD_VALUE=3300; PREFETCH_ENABLE=1; INSTRUCTION_CACHE_ENABLE=1; DATA_CACHE_ENABLE=1; STM32F413xx
  ICCARM.CCIncludePath2: ../Inc; ../../../middlewares/FreeRTOS/Source/Include; ../../../middlewares/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../../../middlewares/FreeRTOS/Source/CMSIS_RTOS; ../../../drivers/STM32F4xx_HAL_Driver/Inc; ../../../drivers/CMSIS/Device/ST/STM32F4xx/Include; ../../../drivers/CMSIS/Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../Inc
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group drivers
    ../../../drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_dma.c stm32f4xx_ll_exti.c stm32f4xx_ll_gpio.c stm32f4xx_ll_rcc.c stm32f4xx_ll_usart.c stm32f4xx_ll_utils.c
  group freeRTOS
    ../../../middlewares/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../middlewares/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../middlewares/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../middlewares/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group src
    ../Src/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group startup
    ./: startup_stm32f413xx.s
